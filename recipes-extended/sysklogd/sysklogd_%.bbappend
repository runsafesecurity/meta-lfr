
# This package builds with PIE disabled
LFR_DISABLE = "1"
TARGET_CC_ARCH_remove = "-fPIC"
