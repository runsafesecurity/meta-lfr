include add-symlinks.inc
